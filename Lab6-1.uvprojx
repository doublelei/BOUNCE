# Keil uVision project Lab6-1.uvprojx, settings and files
target Lab6-1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _Lab6-1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Board;.\User;.\Core;.\Fw_lib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Fw_lib
    ./Fw_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ./Core/: startup_stm32f10x_hd.s core_cm3.c system_stm32f10x.c
  group Board
    ./Board/: EIE3810_Buzzer.c EIE3810_Buzzer.h EIE3810_Clock.c EIE3810_Clock.h EIE3810_Interrupt.c EIE3810_Interrupt.h EIE3810_TFTLCD.c EIE3810_TFTLCD.h Font.H EIE3810_JOYPAD.c EIE3810_JOYPAD.h EIE3810_Timer.c EIE3810_Timer.h EIE3810_USART.c EIE3810_USART.h EIE3810_Key.c EIE3810_Key.h
  group User
    ./User/: main.c stm32f10x_it.c
